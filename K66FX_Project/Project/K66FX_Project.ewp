# IAR project K66FX_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\App\Inc; ..\Bsp\Inc; ..\Startup\Startup; ..\Startup\Lib; D:\file_kinetis\K66FX_Project\Startup\Startup\IAR-ARM; ..\User\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: K66FX_Project.hex
  ILINK.IlinkOutputFile: K66FX_Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App/Inc
    ../App/Inc/: Common.h Include.h Peripheral_IIC.h Peripheral_MPU6050.h Peripheral_OLED.h
  group App/Src
    ../App/Src/: Common.c Peripheral_IIC.c Peripheral_MPU6050.c Peripheral_OLED.c
  group Bsp/Inc
    ../Bsp/Inc/: MK66_adc.h MK66_cmt.h MK66_dac.h MK66_dma.h MK66_flash.h MK66_ftm.h MK66_gpio.h MK66_i2c.h MK66_lptmr.h MK66_pit.h MK66_port.h MK66_port_cfg.h MK66_rtc.h MK66_sdhc.h MK66_spi.h MK66_systick.h MK66_uart.h MK66_wdog.h
  group Bsp/Src
    ../Bsp/Src/: MK66_adc.c MK66_cmt.c MK66_dac.c MK66_dma.c MK66_flash.c MK66_ftm.c MK66_gpio.c MK66_i2c.c MK66_lptmr.c MK66_pit.c MK66_port.c MK66_rtc.c MK66_sdhc.c MK66_spi.c MK66_systick.c MK66_uart.c MK66_wdog.c
  group Doc
    ../Doc/: Readme.txt Version.txt
  group Startup/Lib
    ../Startup/Lib/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group Startup/startup
    ../Startup/Startup/: Misc.c Misc.h MK66F18.h system_MK66.c system_MK66.h
  group Startup/startup/IAR-ARM
    ../Startup/Startup/IAR-ARM/: startup_MK66F18.s
  group User/Inc
    ../User/Inc/: isr.h
  group User/Src
    ../User/Src/: isr.c main.c
